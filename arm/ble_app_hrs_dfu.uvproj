# Keil uVision project ble_app_hrs_dfu.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_hrs_dfu +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 BLE_DFU_APP_SUPPORT  DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310 S110
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\device_manager;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\sd_common;..\..\..\..\..\Include\sdk;..\..\..\..\..\Include\bootloader_dfu
  memory RVCT4: ROM 0x00016000 size 0x00029000
  memory RVCT9: RAM 0x20002000 size 0x00002000
  group Startup Code
    ./../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ./../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
  group Services
    ../../../../../Source/ble/ble_services/: ble_dis.c ble_bas.c ble_hrs.c
  group Libraries
    ../../../../../Source/ble/: ble_error_log.c ble_advdata.c ble_sensorsim.c ble_conn_params.c ble_debug_assert_handler.c
    ../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../../../../../Source/app_common/: app_timer.c pstorage.c crc16.c app_trace.c
    ../../../../../Source/sd_common/: softdevice_handler.c
    ../../../../../Source/simple_uart/: simple_uart.c
    ../../../../../Source/ble/device_manager/: device_manager_peripheral.c
  group Dfu
    ../../../../../Source/bootloader_dfu/: bootloader_util_arm.c dfu_app_handler.c
    ../../../../../Source/ble/ble_services/: ble_dfu.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: ble_app_hrs_dfu +hex
  c flags: Optim=1 wLevel=2
  c define: as above
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x00016000 size 0x00009000
  memory RVCT9: RAM 0x20002000 size 0x00002000
